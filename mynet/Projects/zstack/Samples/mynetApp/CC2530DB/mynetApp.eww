<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mynetApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>mynetApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>mynetApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>mynetApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>mynetApp</project>
        <configuration>CoordinatorEB-Pro</configuration>
      </member>
      <member>
        <project>mynetApp</project>
        <configuration>RouterEB-Pro</configuration>
      </member>
      <member>
        <project>mynetApp</project>
        <configuration>EndDeviceEB-Pro</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


